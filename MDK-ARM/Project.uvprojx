# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32C616x5 Puya
  pack: Puya.PY32C616_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32C616x5,USE_FULL_LL_DRIVER
  c include: ..\Drivers\CMSIS\Include;..\Drivers\PY32C6xx_HAL_Driver\Inc;..\Inc;..\Drivers\CMSIS\Device\PY32C6xx\Include;..\Drivers\BSP\PY32C616xx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ../Src/: system_py32c6xx.c
    ./: startup_py32c616xx.s
  group Application/User
    ../Src/: main.c py32c6xx_it.c bsp.c DigiTube.c
  group BSP/py32c616xx_Start_Kit
    ../Drivers/BSP/PY32C616xx_Start_Kit/: py32c616xx_ll_Start_Kit.c
  group Drivers/PY32C6xx_HAL_Driver
    ../Drivers/PY32C6xx_HAL_Driver/Src/: py32c6xx_ll_utils.c py32c6xx_ll_gpio.c py32c6xx_hal.c py32c6xx_hal_adc.c py32c6xx_hal_comp.c py32c6xx_hal_cortex.c py32c6xx_hal_crc.c py32c6xx_hal_dma.c py32c6xx_hal_exti.c py32c6xx_hal_flash.c py32c6xx_hal_gpio.c py32c6xx_hal_iwdg.c py32c6xx_hal_led.c py32c6xx_hal_lptim.c py32c6xx_hal_pwr.c py32c6xx_hal_rcc.c py32c6xx_hal_rcc_ex.c py32c6xx_hal_tim.c py32c6xx_hal_tim_ex.c py32c6xx_hal_wwdg.c py32c6xx_ll_adc.c py32c6xx_ll_comp.c py32c6xx_ll_crc.c py32c6xx_ll_dma.c py32c6xx_ll_exti.c py32c6xx_ll_led.c py32c6xx_ll_lptim.c py32c6xx_ll_pwr.c py32c6xx_ll_rcc.c py32c6xx_ll_tim.c
